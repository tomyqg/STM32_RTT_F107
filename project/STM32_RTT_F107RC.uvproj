# Keil uVision project STM32_RTT_F107RC.uvproj, settings and files
target STM32_RTT_F107RC (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32_RTT_F107RC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\..\STM32_RTT_F107;..\components\CMSIS\Include;..\components\dfs;..\components\dfs\include;..\components\DeviceDrivers;..\components\finsh;..\components\net\lwip-1.4.1\src;..\components\net\lwip-1.4.1\src\arch\include;..\components\net\lwip-1.4.1\src\include;..\components\net\lwip-1.4.1\src\include\ipv4;..\components\net\lwip-1.4.1\src\netif;..\rtt\include;..\libcpu\arm\common;..\libcpu\arm\cortex-m3;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\applications;..\drivers;..\ECU\main\inc;..\Test\inc;..\ECU\NTP\inc;..\components\net\ethernet;..\components\net\WIFI;..\applications;..\components\armlibc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ../applications/: application.c startup.c threadlist.c
  group Drivers
    ../drivers/: board.c completion.c dataqueue.c platform.c stm32f10x_it.c usart.c serial.c ds1302z_rtc.c led.c W25Q64Flash.c Flash_24L512.c key.c rt_stm32f10x_spi.c
  group STM32_StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Kernel
    ../rtt/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c udelay.c
  group CORTEX-M3
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../components/DeviceDrivers/: rtc.c spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../components/net/ethernet/: eth@stm32.c ethernet.c Lan8720A.c
    ../components/net/WIFI/: usr_wifi232.c
  group finish
    ../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LwIP
    ../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group Test
    ../Test/src/: tcpClient.c tcpServer.c readwrite.c listdir.c readspeed.c seekdir.c writespeed.c
  group ECU_main
    ../ECU/main/src/: checkdata.c debug.c main-thread.c resolve.c zigbee.c datetime.c file.c
  group FileSystem
    ../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../components/dfs/filesystems/elmfat/: ff.c dfs_elm.c
  group ECU_NTP
    ../ECU/NTP/src/: ntpapp.c ntpcomm.c
  group LIBC
    ../components/armlibc/: libc_syms.c mem_std.c stubs.c
